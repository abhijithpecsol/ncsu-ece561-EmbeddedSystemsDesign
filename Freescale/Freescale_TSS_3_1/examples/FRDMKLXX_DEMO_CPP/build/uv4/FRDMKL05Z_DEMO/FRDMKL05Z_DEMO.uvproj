# Keil uVision project FRDMKL05Z_DEMO.uvproj, settings and files
target FRDMKL05Z_DEMO (ARM-ADS)
  device: MKL05Z32xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFFC00-0x1FFFFFFF) IRAM2(0x20000000-0x20000BFF) IROM(0x0-0x07FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: FRDML05Z48M_DEMO
  c flags: OneElfS=1
  c define: FREEDOM, FRDM_KL05Z48
  c misc: --diag_suppress=368
  c include: ..\..\..\src;..\..\..\src\mcu_init\cpu;..\..\..\src\mcu_init\drivers\uart;..\..\..\src\mcu_init\drivers\wdog;..\..\..\src;..\..\..\src\frdmkl05z48m;..\..\..\..\..\GUI\source\src_common;..\..\..\..\..\GUI\source\src_platforms\Kxx;..\..\..\..\..\LIB\shared;..\..\..\..\..\LIB\lib_uv4;..\..\..\src\mcu_init\common;..\..\..\src\mcu_init\cpu;..\..\..\src\mcu_init\platforms;..\..\..\src\mcu_init\drivers\mcg;..\..\..\..\..\LIB\wrapper_cpp
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x400
  memory RVCT10: RAM 0x20000000 size 0xc00
  group Mcu_Init
    ../../../src/mcu_init/common/: io.h io.c common.h assert.h assert.c
    ../../../src/mcu_init/cpu/: arm_cm0.c arm_cm0.h sysinit.h sysinit_kl05.c
    ../../../src/mcu_init/drivers/mcg/: mcg_kl05.c mcg_kl05.h
    ../../../src/mcu_init/drivers/uart/: uart.c uart.h
    ../../../src/mcu_init/drivers/wdog/: wdog.h wdog_kl25.c
  group TSS
    ../../../../../LIB/shared/: TSS_API.h TSS_DataTypes.h TSS_Freemaster.c TSS_GPIO.h TSS_Sensor.c TSS_Sensor.h TSS_SensorGPIO.c TSS_SensorGPIO.h TSS_SensorTSI.c TSS_SensorTSI.h TSS_SensorTSIL.c TSS_SensorTSIL.h TSS_StatusCodes.h TSS_SystemSetupData.c TSS_SystemSetupVal.h TSS_Timer.h
    ../../../../../LIB/lib_uv4/: TSS_KXX_M0.lib
  group Sources
    ../../../src/: main.h main.cpp TSS_SystemSetupGlobal.h
    ../../../src/frdmkl05z48m/: isr.h TSS_SystemSetup.h
  group Project_Headers
    ../../../src/twrkl05z48m/: derivative.h MKL05Z4.h
  group Startup_Code
    ./: startup_MKL05Z4.s system_MKL05Z4.c
  group Wrapper_CPP
    ../../../../../LIB/wrapper_cpp/: TSS_cpp.cpp TSS_cpp.h TSS_cpp_arotary.cpp TSS_cpp_aslider.cpp TSS_cpp_const.h TSS_cpp_keypad.cpp TSS_cpp_matrix.cpp TSS_cpp_rotary.cpp TSS_cpp_slider.cpp
  group Board
    ../../../src/frdmkl05z48m/: board.c board.h
