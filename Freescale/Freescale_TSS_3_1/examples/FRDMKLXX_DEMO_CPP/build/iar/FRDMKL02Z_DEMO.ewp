# IAR project FRDMKL02Z_DEMO.ewp, settings and files
configuration FLASH_32KB_KL02 (ARM, debug)
  General.OGChipSelectEditMenu: MKL02Z32xxx4 Freescale MKL02Z32xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; FREEDOM; FRDM_KL02Z48
  ICCARM.CCIncludePath2: ..\..\src\mcu_init\common; ..\..\src\mcu_init\cpu; ..\..\src\mcu_init\cpu\headers; ..\..\src\mcu_init\drivers\uart; ..\..\src\mcu_init\drivers\mcg; ..\..\src\mcu_init\drivers\wdog; ..\..\src\mcu_init\platforms; includes; ..\..\src; ..\..\src\frdmkl02z48m; ..\..\..\..\GUI\source\src_common; ..\..\..\..\GUI\source\src_platforms\Kxx; ..\..\..\..\LIB\lib_iar; ..\..\..\..\LIB\shared; ..\..\..\..\LIB\wrapper_cpp; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: FRDMKL02Z_DEMO.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: config files\32KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Headers
    ../../src/frdmkl02z48m/: derivative.h MKL02Z4.h
  group Mcu_Init/common
    ../../src/mcu_init/common/: assert.c assert.h common.h io.c io.h startup.c startup.h
  group Mcu_Init/cpu
    ../../src/mcu_init/cpu/: arm_cm0.c arm_cm0.h crt0_cm0.s start.c start.h sysinit.h sysinit_kl02.c vectors.c vectors.h
  group Mcu_Init/drivers/mcg
    ../../src/mcu_init/drivers/mcg/: mcg_kl02.c mcg_kl02.h
  group Mcu_Init/drivers/uart
    ../../src/mcu_init/drivers/uart/: uart.c uart.h
  group Mcu_Init/drivers/wdog
    ../../src/mcu_init/drivers/wdog/: wdog.h wdog_kl25.c
  group Sources
    ../../src/: freemaster_cfg.h main.cpp main.h TSS_SystemSetupGlobal.h
    ../../src/frdmkl02z48m/: isr.h TSS_SystemSetup.h
  group Sources/Board
    ../../src/frdmkl02z48m/: board.c board.h
  group Sources/TSS
    ../../../../LIB/shared/: TSS_API.h TSS_DataTypes.h TSS_Freemaster.c TSS_GPIO.h TSS_Sensor.c TSS_Sensor.h TSS_SensorGPIO.c TSS_SensorGPIO.h TSS_SensorTSI.c TSS_SensorTSI.h TSS_SensorTSIL.c TSS_SensorTSIL.h TSS_StatusCodes.h TSS_SystemSetupData.c TSS_SystemSetupVal.h TSS_Timer.h
    ../../../../LIB/lib_iar/: TSS_KXX_M0.a
  group Wrapper_CPP
    ../../../../LIB/wrapper_cpp/: TSS_cpp.cpp TSS_cpp.h TSS_cpp_arotary.cpp TSS_cpp_aslider.cpp TSS_cpp_const.h TSS_cpp_keypad.cpp TSS_cpp_matrix.cpp TSS_cpp_rotary.cpp TSS_cpp_slider.cpp
