# IAR project FRDMKL25Z_DEMO.ewp, settings and files
configuration FLASH_128KB_KL25 (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; FREEDOM; FRDM_KL25Z48
  ICCARM.CCIncludePath2: ..\..\src\mcu_init\common; ..\..\src\mcu_init\cpu; ..\..\src\mcu_init\cpu\headers; ..\..\src\mcu_init\drivers\uart; ..\..\src\mcu_init\drivers\mcg; ..\..\src\mcu_init\drivers\wdog; ..\..\src\mcu_init\platforms; includes; ..\..\src; ..\..\src\frdmkl25z48m; ..\..\..\..\GUI\source\src_common; ..\..\..\..\LIB\wrapper_cpp; ..\..\..\..\GUI\source\src_platforms\Kxx; ..\..\src\module_id; ..\..\..\..\LIB\lib_iar; ..\..\..\..\LIB\shared; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: FRDMKL25Z_DEMO.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config files\128KB_Pflash_kl25.icf
  ILINK.IlinkExtraOptions: --cpp_init_routine __iar_cstart_call_ctors
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Headers
    ../../src/frdmkl25z48m/: derivative.h MKL25Z4.h
  group Mcu_Init/common
    ../../src/mcu_init/common/: assert.c assert.h common.h io.c io.h startup.c startup.h
  group Mcu_Init/cpu
    ../../src/mcu_init/cpu/: arm_cm0.c arm_cm0.h crt0_cm0.s start.c start.h sysinit.h sysinit_kl25.c vectors.c vectors.h
  group Mcu_Init/drivers/mcg
    ../../src/mcu_init/drivers/mcg/: mcg_kl25.c mcg_kl25.h
  group Mcu_Init/drivers/uart
    ../../src/mcu_init/drivers/uart/: uart.c uart.h
  group Mcu_Init/drivers/wdog
    ../../src/mcu_init/drivers/wdog/: wdog.h wdog_kl25.c
  group Sources
    ../../src/frdmkl25z48m/: isr.h TSS_SystemSetup.h
    ../../src/: main.cpp main.h TSS_SystemSetupGlobal.h
  group Sources/Board
    ../../src/frdmkl25z48m/: board.c board.h
  group Sources/TSS
    ../../../../LIB/shared/: TSS_API.h TSS_DataTypes.h TSS_Freemaster.c TSS_GPIO.h TSS_Sensor.c TSS_Sensor.h TSS_SensorGPIO.c TSS_SensorGPIO.h TSS_SensorTSI.c TSS_SensorTSI.h TSS_SensorTSIL.c TSS_SensorTSIL.h TSS_StatusCodes.h TSS_SystemSetupData.c TSS_SystemSetupVal.h TSS_Timer.h
    ../../../../LIB/lib_iar/: TSS_KXX_M0.a
  group Wrapper_CPP
    ../../../../LIB/wrapper_cpp/: TSS_cpp.cpp TSS_cpp.h TSS_cpp_arotary.cpp TSS_cpp_aslider.cpp TSS_cpp_const.h TSS_cpp_keypad.cpp TSS_cpp_matrix.cpp TSS_cpp_rotary.cpp TSS_cpp_slider.cpp
