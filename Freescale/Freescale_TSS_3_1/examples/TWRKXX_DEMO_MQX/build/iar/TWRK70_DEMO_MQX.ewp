# IAR project TWRK70_DEMO_MQX.ewp, settings and files
configuration FLASH_1024KB_DEBUG (ARM, debug)
  General.OGChipSelectEditMenu: MK70FN1M0xxx12 Freescale MK70FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\src; ..\..\mqx_lib\twrk70f120m.iar\release\bsp\TSS; ..\..\mqx_lib\twrk70f120m.iar\release\bsp; ..\..\mqx_lib\twrk70f120m.iar\release\psp; ..\..\mqx_lib\twrk70f120m.iar\release\shell; ..\..\mqx_lib\twrk70f120m.iar\release\bsp\Generated_Code; ..\..\mqx_lib\twrk70f120m.iar\release
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: TWRK70_DEMO_MQX.out
  ILINK.IlinkIcfFile: ..\..\mqx_lib\twrk70f120m.iar\release\bsp\intflash_sramdata.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group MQX Libraries
    ../../mqx_lib/twrk70f120m.iar/release/bsp/: bsp.a
    ../../mqx_lib/twrk70f120m.iar/release/psp/: psp.a
    ../../mqx_lib/twrk70f120m.iar/release/shell/: shell.a
  group Sources
    ../../src/: hmi.c
  group Sources/TSS
    ../../mqx_lib/twrk70f120m.iar/release/bsp/: tss.a
