<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TWRK40_DEMO_MQX.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TWRK53_DEMO_MQX.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TWRK60_DEMO_MQX.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TWRK70_DEMO_MQX.ewp</path>
  </project>
  <batchBuild/>
</workspace>


