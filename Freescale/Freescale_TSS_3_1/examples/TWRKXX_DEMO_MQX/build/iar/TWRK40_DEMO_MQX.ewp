# IAR project TWRK40_DEMO_MQX.ewp, settings and files
configuration FLASH_256KB_DEBUG (ARM, debug)
  General.OGChipSelectEditMenu: MK40DX256Zxxx10 Freescale MK40DX256Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\src; ..\..\mqx_lib\twrk40x256.iar\release\bsp\TSS; ..\..\mqx_lib\twrk40x256.iar\release\bsp; ..\..\mqx_lib\twrk40x256.iar\release\psp; ..\..\mqx_lib\twrk40x256.iar\release\shell; ..\..\mqx_lib\twrk40x256.iar\release\bsp\Generated_Code; ..\..\mqx_lib\twrk40x256.iar\release
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TWRK40_DEMO_MQX.srec
  ILINK.IlinkOutputFile: TWRK40_DEMO_MQX.out
  ILINK.IlinkIcfFile: ..\..\mqx_lib\twrk40x256.iar\release\bsp\intflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group MQX Libraries
    ../../mqx_lib/twrk40x256.iar/release/bsp/: bsp.a
    ../../mqx_lib/twrk40x256.iar/release/psp/: psp.a
    ../../mqx_lib/twrk40x256.iar/release/shell/: shell.a
  group Sources
    ../../src/: hmi.c
  group Sources/TSS
    ../../mqx_lib/twrk40x256.iar/release/bsp/: tss.a
