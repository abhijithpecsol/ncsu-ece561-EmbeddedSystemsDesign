<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TWRKL05Z48M_DEMO.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TWRKL25Z48M_DEMO.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TWRKL46Z48M_DEMO.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>TWRKL05Z48M_DEMO</project>
        <configuration>FLASH_32KB</configuration>
      </member>
      <member>
        <project>TWRKL25Z48M_DEMO</project>
        <configuration>FLASH_128KB</configuration>
      </member>
      <member>
        <project>TWRKL46Z48M_DEMO</project>
        <configuration>FLASH_256KB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


