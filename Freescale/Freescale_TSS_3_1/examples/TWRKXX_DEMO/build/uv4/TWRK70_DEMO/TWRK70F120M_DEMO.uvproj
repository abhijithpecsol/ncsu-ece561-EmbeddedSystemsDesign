# Keil uVision project TWRK70F120M_DEMO.uvproj, settings and files
target TWRK70F120M_DEMO (ARM-ADS)
  device: MK70FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: TWRK70_DEMO +hex
  c flags: Optim=1 OneElfS=1
  c define: TOWER
  c include: ..\..\..\src\mcu_init\cpu;..\..\..\src\mcu_init\drivers\uart;..\..\..\src\mcu_init\drivers\wdog;..\..\..\src\module_id;..\..\..\src;..\..\..\src\twrk70f120m;..\..\..\..\..\GUI\source\src_common;..\..\..\..\..\GUI\source\src_platforms\Kxx;..\..\..\..\..\LIB\shared;..\..\..\..\..\LIB\lib_uv4;..\..\..\src\mcu_init\common;..\..\..\src\mcu_init\cpu;..\..\..\src\mcu_init\drivers\mcg
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group App_Init
    ../../../src/: app_init.c app_init.h
  group Events
    ../../../src/: events.c events.h
  group FreeMASTER
    ../../../../../GUI/source/src_common/: freemaster_appcmd.c freemaster_bdm.c freemaster_can.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_tsa.c
    ../../../../../GUI/source/src_platforms/Kxx/: freemaster.h freemaster_Kxx.c freemaster_Kxx.h
  group Mcu_Init
    ../../../src/mcu_init/cpu/: arm_cm4.c arm_cm4.h sysinit.h sysinit_k70.c
    ../../../src/mcu_init/drivers/uart/: uart.c uart.h
    ../../../src/mcu_init/drivers/wdog/: wdog.c wdog.h
    ../../../src/mcu_init/common/: common.h
    ../../../src/mcu_init/drivers/mcg/: mcg_k70.c mcg_k70.h
  group Module_Id
    ../../../src/module_id/: module_id.c module_id.h
  group TSS
    ../../../../../LIB/shared/: TSS_API.h TSS_DataTypes.h TSS_Freemaster.c TSS_GPIO.h TSS_Sensor.c TSS_Sensor.h TSS_SensorGPIO.c TSS_SensorGPIO.h TSS_SensorTSI.c TSS_SensorTSI.h TSS_SensorTSIL.c TSS_SensorTSIL.h TSS_StatusCodes.h TSS_SystemSetupData.c TSS_SystemSetupVal.h TSS_Timer.h
    ../../../../../LIB/lib_uv4/: TSS_KXX_M4.lib
  group Sources
    ../../../src/: freemaster_cfg.h main.c main.h TSS_SystemSetupGlobal.h
    ../../../src/twrk70f120m/: isr.h TSS_SystemSetup.h
  group Project_Headers
    ../../../src/twrk60n512/: derivative.h
    ../../../src/twrk70f120m/: MK70F15.h
  group Startup_Code
    ./: startup_MK70F12.s system_MK70F12.c
  group Board
    ../../../src/twrk70f120m/: board.c board.h
