# Keil uVision project TWRK40X256_DEMO.uvproj, settings and files
target TWR40X256_DEMO (ARM-ADS)
  device: MK40X256VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF8000-0x1FFFFFFF) IRAM2(0x20000000-0x20007FFF) IROM(0x0-0x3FFFF) IROM2(0x10000000-0x1003FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: TWRK40_DEMO +hex
  c flags: Optim=1 OneElfS=1
  c define: TOWER
  c include: ..\..\..\src\mcu_init\cpu;..\..\..\src\mcu_init\drivers\uart;..\..\..\src\mcu_init\drivers\wdog;..\..\..\src\module_id;..\..\..\src;..\..\..\src\twrk40x256;..\..\..\..\..\GUI\source\src_common;..\..\..\..\..\GUI\source\src_platforms\Kxx;..\..\..\..\..\LIB\shared;..\..\..\..\..\LIB\lib_uv4;..\..\..\src\mcu_init\common;..\..\..\src\mcu_init\cpu;..\..\..\src\mcu_init\drivers\mcg
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group App_Init
    ../../../src/: app_init.c app_init.h
  group Events
    ../../../src/: events.c events.h
  group FreeMASTER
    ../../../../../GUI/source/src_common/: freemaster_appcmd.c freemaster_bdm.c freemaster_can.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_tsa.c
    ../../../../../GUI/source/src_platforms/Kxx/: freemaster.h freemaster_Kxx.c freemaster_Kxx.h
  group Mcu_Init
    ../../../src/mcu_init/cpu/: arm_cm4.c arm_cm4.h sysinit.c sysinit.h
    ../../../src/mcu_init/drivers/uart/: uart.c uart.h
    ../../../src/mcu_init/drivers/wdog/: wdog.c wdog.h
    ../../../src/mcu_init/drivers/mcg/: mcg.c mcg.h
    ../../../src/mcu_init/common/: common.h
  group Module_Id
    ../../../src/module_id/: module_id.c module_id.h
  group TSS
    ../../../../../LIB/shared/: TSS_API.h TSS_DataTypes.h TSS_Freemaster.c TSS_GPIO.h TSS_Sensor.c TSS_Sensor.h TSS_SensorGPIO.c TSS_SensorGPIO.h TSS_SensorTSI.c TSS_SensorTSI.h TSS_SensorTSIL.c TSS_SensorTSIL.h TSS_StatusCodes.h TSS_SystemSetupData.c TSS_SystemSetupVal.h TSS_Timer.h
    ../../../../../LIB/lib_uv4/: TSS_KXX_M4.lib
  group Sources
    ../../../src/: freemaster_cfg.h main.c main.h TSS_SystemSetupGlobal.h
    ../../../src/twrk40x256/: isr.h TSS_SystemSetup.h
  group Project_Headers
    ../../../src/twrk40x256/: derivative.h MK40DZ10.h
  group Startup_Code
    ./: startup_MK40N512MD100.s system_MK40N512MD100.c
  group Board
    ../../../src/twrk40x256/: board.c board.h
