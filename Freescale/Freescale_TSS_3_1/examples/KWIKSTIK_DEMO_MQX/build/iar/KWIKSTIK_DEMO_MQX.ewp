# IAR project KWIKSTIK_DEMO_MQX.ewp, settings and files
configuration RAM_64KB_Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\src; ..\..\mqx_lib\kwikstikk40x256.iar\release\bsp\TSS; ..\..\mqx_lib\kwikstikk40x256.iar\release\bsp; ..\..\mqx_lib\kwikstikk40x256.iar\release\psp; ..\..\mqx_lib\kwikstikk40x256.iar\release\shell; ..\..\mqx_lib\kwikstikk40x256.iar\release\bsp\Generated_Code; ..\..\mqx_lib\kwikstikk40x256.iar\release
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: KWIKSTIK_DEMO_MQX.srec
  ILINK.IlinkOutputFile: kwikstik_demo_mqx.out
  ILINK.IlinkIcfFile: ..\..\mqx_lib\kwikstikk40x256.iar\release\bsp\ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_256KB_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK40DX256Zxxx10 Freescale MK40DX256Zxxx10
  ILINK.IlinkIcfFile: ..\..\mqx_lib\kwikstikk40x256.iar\release\bsp\intflash.icf
  group MQX Libraries
    ../../mqx_lib/kwikstikk40x256.iar/release/bsp/: bsp.a
    ../../mqx_lib/kwikstikk40x256.iar/release/psp/: psp.a
    ../../mqx_lib/kwikstikk40x256.iar/release/shell/: shell.a
  group Sources
    ../../src/: hmi.c
  group Sources/TSS
    ../../mqx_lib/kwikstikk40x256.iar/release/bsp/: tss.a
