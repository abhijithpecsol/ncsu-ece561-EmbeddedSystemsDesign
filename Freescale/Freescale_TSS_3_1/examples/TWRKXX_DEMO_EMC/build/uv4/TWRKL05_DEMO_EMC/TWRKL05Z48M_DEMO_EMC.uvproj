# Keil uVision project TWRKL05Z48M_DEMO_EMC.uvproj, settings and files
target TWRKL05Z48M_DEMO (ARM-ADS)
  device: MKL05Z32xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFFC00-0x1FFFFFFF) IRAM2(0x20000000-0x20000BFF) IROM(0x0-0x07FFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: TWRKL05Z48M_DEMO
  c flags: Optim=4
  c define: TOWER
  c include: ..\..\..\src\mcu_init\cpu;..\..\..\src\mcu_init\drivers\uart;..\..\..\src\mcu_init\drivers\wdog;..\..\..\src\module_id;..\..\..\src;..\..\..\src\twrkl05z48m;..\..\..\..\..\GUI\source\src_common;..\..\..\..\..\GUI\source\src_platforms\Kxx;..\..\..\..\..\LIB\shared;..\..\..\..\..\LIB\lib_uv4;..\..\..\src\mcu_init\common;..\..\..\src\mcu_init\cpu;..\..\..\src\mcu_init\drivers\mcg
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x400
  memory RVCT10: RAM 0x20000000 size 0xc00
  group App_Init
    ../../../src/: app_init.c app_init.h
  group Events
    ../../../src/: events.c events.h
  group FreeMASTER
    ../../../../../GUI/source/src_common/: freemaster_appcmd.c freemaster_bdm.c freemaster_can.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_tsa.c
    ../../../../../GUI/source/src_platforms/Kxx/: freemaster.h freemaster_Kxx.c freemaster_Kxx.h
  group Mcu_Init
    ../../../src/mcu_init/common/: common.h
    ../../../src/mcu_init/cpu/: arm_cm0.c arm_cm0.h sysinit.h sysinit_kl05.c
    ../../../src/mcu_init/drivers/mcg/: mcg_kl05.c mcg_kl05.h
    ../../../src/mcu_init/drivers/wdog/: wdog.h wdog_kl25.c
    ../../../src/mcu_init/drivers/uart/: uart_kl05.c uart_kl05.h
  group Module_Id
    ../../../src/module_id/: module_id.c module_id.h
  group TSS
    ../../../../../LIB/shared/: TSS_API.h TSS_DataTypes.h TSS_Freemaster.c TSS_GPIO.h TSS_Sensor.c TSS_Sensor.h TSS_SensorGPIO.c TSS_SensorGPIO.h TSS_SensorTSI.c TSS_SensorTSI.h TSS_SensorTSIL.c TSS_SensorTSIL.h TSS_StatusCodes.h TSS_SystemSetupData.c TSS_SystemSetupVal.h TSS_Timer.h
    ../../../../../LIB/lib_uv4/: TSS_KXX_M0.lib
  group Sources
    ../../../src/: freemaster_cfg.h main.c main.h TSS_SystemSetupGlobal.h
    ../../../src/twrkl05z48m/: isr.h TSS_SystemSetup.h
  group Project_Headers
    ../../../src/twrkl05z48m/: derivative.h MKL05Z4.h
  group Startup_Code
    ./: startup_MKL05Z4.s system_MKL05Z4.c
  group Board
    ../../../src/twrkl05z48m/: board.c board.h
