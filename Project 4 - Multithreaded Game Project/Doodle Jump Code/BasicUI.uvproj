# Keil uVision project BasicUI.uvproj, settings and files
target KL25Z Flash (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: BasicUI
  c flags: Optim=2
  c misc: --fpmode=fast
  c include: .\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  group Startup
    ./src/: system_MKL25Z4.c
    ./asm/: startup_MKL25Z4.s
  group source
    ./src/: main.c LEDs.c timers.c i2c.c mma8451.c delay.c profile.c region.c lucida_8x13.c lucida_12x19.c lucida_20x31.c tft_lcd.c tft_text.c RTX_Config.c sound.c tasks.c tft_graphics.c game.c camera.c
