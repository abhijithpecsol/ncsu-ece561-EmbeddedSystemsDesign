# IAR project KWIKSTIK_DEMO.ewp, settings and files
configuration RAM_64KB (ARM, debug)
  General.OGChipSelectEditMenu: MK40DX256Zxxx10 Freescale MK40DX256Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TOWER
  ICCARM.CCDiagSuppress: Pe174,Pe767
  ICCARM.CCIncludePath2: ..\..\src\mcu_init\common; ..\..\src\mcu_init\cpu; ..\..\src\mcu_init\cpu\headers; ..\..\src\mcu_init\drivers\uart; ..\..\src\mcu_init\drivers\mcg; ..\..\src\mcu_init\drivers\wdog; ..\..\src\mcu_init\platforms; includes; ..\..\src; ..\..\src\slcd; ..\..\src\buzzer; ..\..\src\twrk40x256; ..\..\..\..\GUI\source\src_common; ..\..\..\..\GUI\source\src_platforms\Kxx; ..\..\..\..\LIB\lib_iar; ..\..\..\..\LIB\shared; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: KWIKSTIK_DEMO.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: config files\64KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_256KB_PFLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkOutputFile: KWIKSTIK_DEMO.out
  ILINK.IlinkIcfFile: config files\256KB_Pflash.icf
  group Headers
    ../../src/twrk40x256/: derivative.h MK40DZ10.h
  group Mcu_Init/common
    ../../src/mcu_init/common/: assert.c assert.h common.h io.c io.h startup.c startup.h
  group Mcu_Init/cpu
    ../../src/mcu_init/cpu/: arm_cm4.c arm_cm4.h crt0.s start.c start.h sysinit.c sysinit.h vectors.c vectors.h
  group Mcu_Init/drivers/mcg
    ../../src/mcu_init/drivers/mcg/: mcg.c mcg.h
  group Mcu_Init/drivers/uart
    ../../src/mcu_init/drivers/uart/: uart.c uart.h
  group Mcu_Init/drivers/wdog
    ../../src/mcu_init/drivers/wdog/: wdog.c wdog.h
  group Mcu_Init/platforms
    ../../src/mcu_init/platforms/: tower.h
  group Sources
    ../../src/: freemaster_cfg.h isr.h main.c main.h TSS_SystemSetup.h
  group Sources/App_Init
    ../../src/: app_init.c app_init.h
  group Sources/Buzzer
    ../../src/buzzer/: Driver_Buzzer.c Driver_Buzzer.h
  group Sources/Events
    ../../src/: events.c events.h
  group Sources/FreeMASTER
    ../../../../GUI/source/src_platforms/Kxx/: freemaster.h freemaster_Kxx.c
    ../../../../GUI/source/src_common/: freemaster_appcmd.c freemaster_can.c freemaster_protocol.c freemaster_rec.c freemaster_scope.c freemaster_serial.c freemaster_tsa.c
  group Sources/SLCD
    ../../src/slcd/: Driver_SLCD.c Fonts_LCD.c
  group Sources/TSS
    ../../../../LIB/shared/: TSS_API.h TSS_DataTypes.h TSS_Freemaster.c TSS_GPIO.h TSS_Sensor.c TSS_Sensor.h TSS_SensorGPIO.c TSS_SensorGPIO.h TSS_SensorTSI.c TSS_SensorTSI.h TSS_SensorTSIL.c TSS_SensorTSIL.h TSS_StatusCodes.h TSS_SystemSetupData.c TSS_SystemSetupVal.h TSS_Timer.h
    ../../../../LIB/lib_iar/: TSS_KXX_M4.a
