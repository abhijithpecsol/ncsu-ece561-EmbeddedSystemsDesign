# IAR project TWRK53_DEMO_MQX.ewp, settings and files
configuration RAM_128KB_DEBUG (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\mqx_lib\twrk53n512.iar\release\bsp\TSS; ..\..\mqx_lib\twrk53n512.iar\release\bsp; ..\..\mqx_lib\twrk53n512.iar\release\psp; ..\..\mqx_lib\twrk53n512.iar\release\shell; ..\..\mqx_lib\twrk53n512.iar\release\bsp\Generated_Code; ..\..\mqx_lib\twrk53n512.iar\release
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: TWRK53_DEMO_MQX.out
  ILINK.IlinkIcfFile: ..\..\mqx_lib\twrk53n512.iar\release\bsp\ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_512KB_DEBUG (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\mqx_lib\twrk53n512.iar\release\bsp\intflash.icf
  group MQX Libraries
    ../../mqx_lib/twrk53n512.iar/release/bsp/: bsp.a
    ../../mqx_lib/twrk53n512.iar/release/psp/: psp.a
    ../../mqx_lib/twrk53n512.iar/release/shell/: shell.a
  group Sources
    ../../src/: hmi.c
  group Sources/TSS
    ../../mqx_lib/twrk53n512.iar/release/bsp/: tss.a
