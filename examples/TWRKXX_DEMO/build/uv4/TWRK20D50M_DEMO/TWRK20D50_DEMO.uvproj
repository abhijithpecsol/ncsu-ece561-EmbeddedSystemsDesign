# Keil uVision project TWRK20D50_DEMO.uvproj, settings and files
target TWRK20D50_DEMO (ARM-ADS)
  device: MK20DN128xxx5 Freescale Semiconductor
  cpu: IRAM(0x1FFFE000-0x1FFFFFFF) IRAM2(0x20000000-0x20001FFF) IROM(0x0-0x1FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ELITTLE
  output: TWRK20D50_DEMO +hex
  c flags: Optim=1 OneElfS=1
  c define: TOWER
  c include: ..\..\..\src\mcu_init\cpu;..\..\..\src\mcu_init\drivers\uart;..\..\..\src\mcu_init\drivers\wdog;..\..\..\src\module_id;..\..\..\src;..\..\..\src\twrk20dx50;..\..\..\..\..\GUI\source\src_common;..\..\..\..\..\GUI\source\src_platforms\Kxx;..\..\..\..\..\LIB\shared;..\..\..\..\..\LIB\lib_uv4;..\..\..\src\mcu_init\common;..\..\..\src\mcu_init\cpu;..\..\..\src\mcu_init\drivers\mcg
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x2000
  group App_Init
    ../../../src/: app_init.c app_init.h
  group Events
    ../../../src/: events.c events.h
  group FreeMASTER
    ../../../../../gui/source/src_common/: freemaster_appcmd.c freemaster_bdm.c freemaster_can.c freemaster_private.h freemaster_protocol.c freemaster_protocol.h freemaster_rec.c freemaster_rec.h freemaster_scope.c freemaster_serial.c freemaster_tsa.c freemaster_tsa.h
    ../../../../../gui/source/src_platforms/Kxx/: freemaster.h freemaster_Kxx.c freemaster_Kxx.h
  group Mcu_Init
    ../../../src/mcu_init/cpu/: arm_cm4.c arm_cm4.h sysinit.h sysinit_k70.c
    ../../../src/mcu_init/drivers/mcg/: mcg_k20.c mcg_k20.h
    ../../../src/mcu_init/drivers/uart/: uart.h uart_k20.c
    ../../../src/mcu_init/drivers/wdog/: wdog.c wdog.h
    ../../../src/mcu_init/common/: common.h
  group Module_Id
    ../../../src/module_id/: module_id.c module_id.h
  group TSS
    ../../../../../lib/shared/: TSS_API.h TSS_DataTypes.h TSS_Freemaster.c TSS_GPIO.h TSS_Sensor.c TSS_Sensor.h TSS_SensorGPIO.c TSS_SensorGPIO.h TSS_SensorTSI.c TSS_SensorTSI.h TSS_SensorTSIL.c TSS_SensorTSIL.h TSS_StatusCodes.h TSS_SystemSetupData.c TSS_SystemSetupVal.h TSS_Timer.h
    ../../../../../LIB/lib_uv4/: TSS_KXX_M4.lib
  group Sources
    ../../../src/: freemaster_cfg.h main.c main.h TSS_SystemSetupGlobal.h
    ../../../src/twrk20dx50/: isr.h TSS_SystemSetup.h
  group Project_Headers
    ../../../src/twrk20dx50/: derivative.h MK20D5.h
  group Startup_Code
    ./: startup_MK20D5.s system_MK20D5.c
  group Board
    ../../../src/twrk20dx50/: board.c board.h
