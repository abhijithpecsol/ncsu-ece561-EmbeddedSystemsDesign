# IAR project TWRK40X256_DEMO.ewp, settings and files
configuration RAM_64KB_K40 (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TOWER
  ICCARM.CCDiagSuppress: Pe174,Pe767
  ICCARM.CCIncludePath2: ..\..\src\mcu_init\projects\gpio_example; ..\..\src\mcu_init\common; ..\..\src\mcu_init\cpu; ..\..\src\mcu_init\cpu\headers; ..\..\src\mcu_init\drivers\uart; ..\..\src\mcu_init\drivers\mcg; ..\..\src\mcu_init\drivers\wdog; includes; ..\..\src; ..\..\src\twrk40x256; ..\..\..\..\GUI\source\src_common; ..\..\..\..\GUI\source\src_platforms\Kxx; ..\..\src\module_id; ..\..\..\..\LIB\lib_iar; ..\..\..\..\LIB\shared; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TWRK40X256_DEMO.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config files\64KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_256KB_PFLASH_K40 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK40DX256xxx10 Freescale MK40DX256xxx10
  ICCARM.CCDefines: IAR; TOWER; TWR_K40X256
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: config files\256KB_Pflash.icf
  group Headers
    ../../src/twrk40x256/: derivative.h MK40DZ10.h
  group Mcu_Init/common
    ../../src/mcu_init/common/: common.h startup.c startup.h
  group Mcu_Init/cpu
    ../../src/mcu_init/cpu/: arm_cm4.c arm_cm4.h crt0.s start.c start.h sysinit.h sysinit_k40.c vectors.c vectors.h
  group Mcu_Init/drivers/mcg
    ../../src/mcu_init/drivers/mcg/: mcg.c mcg.h
  group Mcu_Init/drivers/uart
    ../../src/mcu_init/drivers/uart/: uart.c uart.h
  group Mcu_Init/drivers/wdog
    ../../src/mcu_init/drivers/wdog/: wdog.c wdog.h
  group Sources
    ../../src/: freemaster_cfg.h main.c main.h TSS_SystemSetupGlobal.h
    ../../src/twrk40x256/: isr.h TSS_SystemSetup.h
  group Sources/App_Init
    ../../src/: app_init.c app_init.h
  group Sources/Board
    ../../src/twrk40x256/: board.c board.h
  group Sources/Events
    ../../src/: events.c events.h
  group Sources/FreeMASTER
    ../../../../GUI/source/src_platforms/Kxx/: freemaster.h freemaster_Kxx.c
    ../../../../GUI/source/src_common/: freemaster_appcmd.c freemaster_can.c freemaster_protocol.c freemaster_rec.c freemaster_scope.c freemaster_serial.c freemaster_tsa.c
  group Sources/Module_Id
    ../../src/module_id/: module_id.c module_id.h
  group Sources/TSS
    ../../../../LIB/shared/: TSS_API.h TSS_DataTypes.h TSS_Freemaster.c TSS_GPIO.h TSS_Sensor.c TSS_Sensor.h TSS_SensorGPIO.c TSS_SensorGPIO.h TSS_SensorTSI.c TSS_SensorTSI.h TSS_SensorTSIL.c TSS_SensorTSIL.h TSS_StatusCodes.h TSS_SystemSetupData.c TSS_SystemSetupVal.h TSS_Timer.h
    ../../../../LIB/lib_iar/: TSS_KXX_M4.a
