# Keil uVision project FRDMKL26Z_DEMO.uvproj, settings and files
target FRDMKL26Z_DEMO (ARM-ADS)
  device: MKL25Z128xxx4 Freescale Semiconductor
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: TWRKL25Z48M_DEMO
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: FREEDOM, FRDM_KL25Z48
  c misc: --diag_suppress=368
  c include: ..\..\..\src;..\..\..\src\mcu_init\cpu;..\..\..\src\mcu_init\drivers\uart;..\..\..\src\mcu_init\drivers\wdog;..\..\..\src\module_id;..\..\..\src\frdmkl26z48m;..\..\..\..\..\GUI\source\src_common;..\..\..\..\..\GUI\source\src_platforms\Kxx;..\..\..\..\..\LIB\shared;..\..\..\..\..\LIB\lib_uv4;..\..\..\src\mcu_init\common;..\..\..\src\mcu_init\cpu;..\..\..\src\mcu_init\platforms;..\..\..\src\mcu_init\drivers\mcg;..\..\..\..\..\LIB\wrapper_cpp
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  group Mcu_Init
    ../../../src/mcu_init/common/: io.h io.c common.h assert.h assert.c
    ../../../src/mcu_init/cpu/: arm_cm0.c arm_cm0.h sysinit.h sysinit_kl25.c
    ../../../src/mcu_init/drivers/uart/: uart.c uart.h
    ../../../src/mcu_init/drivers/wdog/: wdog.h wdog_kl25.c
    ../../../src/mcu_init/drivers/mcg/: mcg_kl25.c mcg_kl25.h
  group TSS
    ../../../../../LIB/shared/: TSS_API.h TSS_DataTypes.h TSS_Freemaster.c TSS_GPIO.h TSS_Sensor.c TSS_Sensor.h TSS_SensorGPIO.c TSS_SensorGPIO.h TSS_SensorTSI.c TSS_SensorTSI.h TSS_SensorTSIL.c TSS_SensorTSIL.h TSS_StatusCodes.h TSS_SystemSetupData.c TSS_SystemSetupVal.h TSS_Timer.h
    ../../../../../LIB/lib_uv4/: TSS_KXX_M0.lib
  group Sources
    ../../../src/: main.h main.cpp TSS_SystemSetupGlobal.h
    ../../../src/frdmkl26z48m/: isr.h TSS_SystemSetup.h
  group Project_Headers
    ../../../src/frdmkl26z48m/: derivative.h MKL26Z4.h
  group Startup_Code
    ./: startup_MKL26Z4.s system_MKL26Z4.c
  group Wrapper_CPP
    ../../../../../LIB/wrapper_cpp/: TSS_cpp.cpp TSS_cpp.h TSS_cpp_arotary.cpp TSS_cpp_aslider.cpp TSS_cpp_const.h TSS_cpp_keypad.cpp TSS_cpp_matrix.cpp TSS_cpp_rotary.cpp TSS_cpp_slider.cpp
  group Board
    ../../../src/frdmkl26z48m/: board.c board.h
